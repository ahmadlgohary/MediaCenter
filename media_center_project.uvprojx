# Keil uVision project media_center_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: media_center_project
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Libraries
    ./: GLCD.h GLCD_SPI_LPC1700.c LED.c LED.h KBD.c KBD.h Font_6x8_h.h Font_16x24_h.h
  group Audio
    ./audio_stream_files/: adcuser.c adcuser.h audio.h core_cm3.c core_cm3.h type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbdmain.c usbdmain.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h
  group Main
    ./: main.c
  group Images
    ./: photo_gallery_images.c photo_gallery_images.h
  group Snake
    ./: snake.c snake.h
  group Did He Run?
    ./: did_he_run_images.c did_he_run_images.h did_he_run_main.c did_he_run_main.h
  group Joke Machine
    ./: jokes.c jokes.h
software components: CMSIS:CORE 5.4.0, Board Support:Buttons 1.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
